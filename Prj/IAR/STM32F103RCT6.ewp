# IAR project STM32F103RCT6.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\Source\APL; ..\..\Source\HAL\Core; ..\..\Source\HAL\Hal; ..\..\Source\HDL; ..\..\Source\HAL\stm32f10x\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103RCT6.hex
  ILINK.IlinkOutputFile: STM32F103RCT6.out
  ILINK.IlinkIcfFile: E:\Work\CodeGit\STM32F103RCT6\Prj\IAR\stm32f103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APL
    ../../Source/APL/: app.c main.c
  group HAL/Core
    ../../Source/HAL/Core/: startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c
  group HAL/Hal
    ../../Source/HAL/Hal/: hal_adc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_rtc.c hal_spi.c hal_uart.c
  group HAL/stm32f10x
    ../../Source/HAL/stm32f10x/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HDL
    ../../Source/HDL/: drv_led.c
